# Keil uVision project 100t 双轴.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F502 Silicon Labs
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0xFFF) CLOCK(24000000)
  output: 9003 +hex
  c flags: Optimize=8
  group Source Group 1
    ./: STARTUP.A51
    ./Src/: AdcDrv.c AngApp.c Calibration.c CmdSub.c Comm.c Delay.c Filter.c Flash.c Init.c Key.c Main.c ModBusCrc.c ModBusRtu.c Send.c Sensor.c Sub.c Timer.c CalMcuT.c compass.c compass.h
