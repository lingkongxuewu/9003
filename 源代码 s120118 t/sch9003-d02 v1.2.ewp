# IAR project sch9003-d02 v1.2.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m88 ATmega88
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 2
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm88.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 1
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$PROJ_FNAME$_eeprom.hex
  group (top)
    src/: Alti.c Baro.c BaroDrv.c Cmd.c Comp.c delay.c Init.c Main.c Sub.c TwiSlave.c
