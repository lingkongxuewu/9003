<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\sch9003-d02 v1.2.ewp</path>
  </project>
  <batchBuild/>
</workspace>


